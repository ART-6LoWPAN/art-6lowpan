# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: app\inc\project_preinc.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ART-6LoWPAN.out
  ILINK.IlinkIcfFile: stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
